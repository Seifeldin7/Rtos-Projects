# Keil uVision project project2.uvproj, settings and files
target Source (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Example016;..\..\FreeRTOS-Source\include;..\..\FreeRTOS-Source\portable\RVDS\ARM_CM3;..\..\FreeRTOS-Source\demo_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group FreeRTOS_source
    ../../FreeRTOS-Source/: list.c queue.c tasks.c
    ../../FreeRTOS-Source/portable/MemMang/: heap_1.c
    ../../FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
  group Demo_source
    ./: main.c vector.c vector.h main.h bool.h
    ../../FreeRTOS-Source/demo_code/: basic_io.c
  group System_source
    ./: startup_MPS_CM3.s
